# Keil uVision project SDS_Recorder.Debug+IMXRT1050-EVKB.uvprojx, settings and files
target Debug+IMXRT1050-EVKB (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.15.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x018000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: SDS_Recorder.axf
  c flags: Optim=1 v6Lang=5
  c define: CMSIS_board_header=\"IMXRT1050_EVKB.h\" CODEC_WM8960_ENABLE FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1 SKIP_SYSCLK_INIT XIP_BOOT_HEADER_DCD_ENABLE=1 XIP_BOOT_HEADER_ENABLE=1 XIP_EXTERNAL_FLASH=1 SDK_I2C_BASED_COMPONENT_USED=1
  c misc: -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality -Wno-macro-redefined -Wno-pragma-pack -Wno-parentheses-equality
  c include: ..\..\framework\interface\audio\include;..\..\framework\interface\gpio\driver\iMXRT1050;..\..\framework\interface\gpio\include;..\..\framework\interface\sensor\include;..\..\framework\layer\Board\IMXRT1050-EVKB;..\..\framework\layer\Board\IMXRT1050-EVKB\Driver
  asm define: as above
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ../../framework/layer/Board/IMXRT1050-EVKB/RTE/Device/MIMXRT1052DVL6B/MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Documentation
    ./: README.md
  group Source Files
    ./: demo_audio.c
  group GPIO Interface
    ../../framework/interface/gpio/include/: Driver_GPIO.h
    ../../framework/interface/gpio/driver/iMXRT1050/: GPIO_iMXRT1050.h GPIO_iMXRT1050.c
  group Board
    ../../framework/layer/Board/IMXRT1050-EVKB/: IMXRT1050_EVKB.h main.h main.c retarget_stdio.c
  group Driver
    ../../framework/interface/audio/include/: audio_drv.h
    ../../framework/interface/sensor/include/: sensor_drv.h
    ../../framework/interface/sensor/source/: sensor_drv.c
    ../../framework/layer/Board/IMXRT1050-EVKB/Driver/: sensor_config.h sensor_drv_hw.c Audio_IMXRT1050-EVKB.h Audio_IMXRT1050-EVKB.c
  group MCUXpresso
    ../../framework/layer/Board/IMXRT1050-EVKB/: IMXRT1050-EVKB.mex
  group Socket
    ../../framework/layer/Socket/MW-Network/ETH/: socket_startup.c
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS-View:Event Recorder 1.5.2, CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, SDS:Buffer 0.9.0, SDS:IO:Socket 0.9.0, SDS:Recorder 0.9.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.18.0, Network:Interface:ETH 7.18.0, Network:Service:DNS Client 7.18.0, Network:Socket:BSD 7.18.0, Network:Socket:TCP 7.18.0, Network:Socket:UDP 7.18.0, CMSIS Driver:Ethernet MAC 1.3.0, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, CMSIS Driver:MCI 1.4.0, CMSIS Driver:VIO:Board 1.1.0, IoT Utility:Socket:MDK Network 1.2.1, Board Support:SDK Drivers:evkbimxrt1050 2.0.1, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:USART:lpuart_cmsis 2.2.0, Device:CMSIS:MIMXRT1052_header 1.0.0, Device:CMSIS:MIMXRT1052_system 1.0.0, Device:SDK Drivers:cache 2.0.4, Device:SDK Drivers:clock 2.4.0, Device:SDK Drivers:codec 2.3.1, Device:SDK Drivers:codec_i2c 2.1.0, Device:SDK Drivers:common 2.3.2, Device:SDK Drivers:dmamux 2.0.5, Device:SDK Drivers:edma 2.4.3, Device:SDK Drivers:enet 2.5.4, Device:SDK Drivers:fxos8700cq 1.0.0, Device:SDK Drivers:gpio 2.0.6, Device:SDK Drivers:i2c 2.3.1, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpi2c_adapter 1.0.0, Device:SDK Drivers:lpuart 2.5.3, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:lpuart_edma 2.5.2, Device:SDK Drivers:nic301 2.0.1, Device:SDK Drivers:sai 2.3.6, Device:SDK Drivers:sai_edma 2.5.0, Device:SDK Drivers:sdhc 2.8.1, Device:SDK Drivers:wm8960 2.2.1, Device:SDK Drivers:wm8960_adapter 2.2.0, Device:SDK Drivers:xip_device 2.0.3, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.1, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
